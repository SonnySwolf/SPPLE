# Keil uVision project SPPLEDemo.uvproj, settings and files
target SPPLEDemo_Debug (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ..\SPPLEDemo +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,DEBUG_ENABLED,HSE_VALUE=8000000,"assert_param(expr)"=" ",__SUPPORT_LOW_ENERGY__
  c misc: --diag_suppress=186,4017
  c include: ..\Platform;..\Platform\stm32f4xx\CMSIS;..\Platform\stm32f4xx\Driver\inc;..\Bluetopia\btpskrnl;..\Bluetopia\btpsvend;..\Bluetopia\btvs;..\Bluetopia\include;..\Bluetopia\profiles\GATT\include;..\Bluetopia\profiles\GAPS\include;..\Action_User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\Platform\rvmdk\STM32F407xG.sct
  group Application
    ../Action_User/: SPPLEDemo.c Main.c
    ../Platform/: HAL.c
  group Bluetopia
    ../Bluetopia/btvs/: BTVS.c
    ../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../Bluetopia/btpsvend/: BTPSVEND.c
    ../Bluetopia/hcitrans/: HCITRANS.c
  group STM32_StdPeriph_Lib
    ../Platform/stm32f4xx/Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_usart.c stm32f4xx_syscfg.c
    ../Platform/stm32f4xx/CMSIS/: system_stm32f4xx.c
    ../Platform/rvmdk/: startup_stm32f40_41xxx.s
  group Libraries
    ../Bluetopia/lib/: Bluetopia.lib
    ../Bluetopia/profiles/GAPS/lib/rvmdk/: SS1BTGAP.lib
    ../Bluetopia/profiles/GATT/lib/rvmdk/: SS1BTGAT.lib
target SPPLEDemo_Release (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: ..\SPPLEDemo +hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F40_41xxx,NDEBUG,HSE_VALUE=25000000,"assert_param(expr)"=" ",__SUPPORT_LOW_ENERGY__
  c misc: --diag_suppress=186,4017
  c include: ..;..\..;..\..\..\..\Platform;..\..\..\..\Platform\stm32f4xx\CMSIS;..\..\..\..\Platform\stm32f4xx\Driver\inc;..\..\..\..\..\Bluetopia\btpskrnl;..\..\..\..\..\Bluetopia\btpsvend;..\..\..\..\..\Bluetopia\btvs;..\..\..\..\..\Bluetopia\hcitrans.dma;..\..\..\..\..\Bluetopia\include;..\..\..\..\..\Bluetopia\profiles\gatt\include;..\..\..\..\..\Bluetopia\profiles\gaps\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\rvmdk\STM32F407xG.sct
