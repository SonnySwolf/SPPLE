LR_IROM 0x08000000 0x00100000
{
   ER_IROM 0x08000000 0x00100000
   {
      *.o (RESET, +First)
      * (InRoot$$Sections, +RO)
   }

   RW_IRAM 0x20000000 0x00020000
   {
      * (+RW, +ZI)
   }
}

